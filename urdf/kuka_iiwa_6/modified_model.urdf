Commit message: Debug: robot

File: urdf/kuka_iiwa_6/modified_model.urdf (robot description, URDF)
Before this commit: robot lbr_iiwa, 13 links, 12 joints
Joints:
- joint tcp_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0.1 0 rpy=-0.3 0.4 0.2
